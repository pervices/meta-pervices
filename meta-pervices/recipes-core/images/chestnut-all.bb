require base-image.inc