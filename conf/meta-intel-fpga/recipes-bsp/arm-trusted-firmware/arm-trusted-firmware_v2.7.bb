require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

ATF_VERSION = "v2.7.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "7d55643fada91159353734a371d4f6005df5fefe"
