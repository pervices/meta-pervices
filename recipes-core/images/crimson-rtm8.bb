require crimson-cyan-base-image.inc
