require base-image.inc
IMAGE_INSTALL += "chestnut-firmware"
IMAGE_INSTALL_remove += "webserver"
