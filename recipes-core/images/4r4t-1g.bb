require base-image.inc
IMAGE_INSTALL += "cyan-firmware-4r4t-1g"
export IMAGE_BASENAME = "4r4t-1g"
