require base-image.inc
IMAGE_INSTALL += "crimson-firmware-rtm7"
