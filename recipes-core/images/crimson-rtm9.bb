require crimson-base-image.inc
