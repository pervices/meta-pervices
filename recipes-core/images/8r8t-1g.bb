require base-image.inc
IMAGE_INSTALL += "cyan-firmware-8r8t-1g"
