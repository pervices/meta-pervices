FILESEXTRAPATHS_prepend := "${THISDIR}/gtk+-${PV}:"
SRC_URI += "file://fix-defined.patch" 