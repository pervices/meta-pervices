SRC_URI = "git://github.com/tmux/tmux.git;protocol=https;branch=master"
