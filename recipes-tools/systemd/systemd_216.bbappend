FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-tempfiles-don-t-create-var-tmp-log-directories.patch"
