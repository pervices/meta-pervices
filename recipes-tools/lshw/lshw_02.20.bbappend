INSANE_SKIP:${PN} = "ldflags"
