FILESEXTRAPATHS_prepend := "${THISDIR}/mtd-utils:"
SRC_URI += "file://mtd-utils-Support-jffs2-flash-erase-for-large-OOB-32b.patch"
