FILES_whiptail = ""
FILES_${PN} += "${bindir}/whiptail"
