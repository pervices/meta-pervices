FILES:whiptail = ""
FILES:${PN} += "${bindir}/whiptail"
